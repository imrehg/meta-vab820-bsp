SRC_URI_append = " default-to-boot-from-the-SD-card.patch"
